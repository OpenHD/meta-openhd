IMAGE_INSTALL:append = " \
    iw612-autoload \
    kernel-module-nxp-wlan \
"
